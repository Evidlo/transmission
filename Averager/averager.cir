*Averager

.INCLUDE rectifiersubcir.cir
.INCLUDE averagersubcir.cir

Vin n_in 0 DC 0 AC sin(2.5 1 14000k)

x1 n_in rect rectifier
x2 rect n_out averager
*x3 n_out n_fin invertingamp

*.control
*	tran .1u 1u
*Graphs input and output of Superdiode
*	plot rect n_out
*	run
*.endc
