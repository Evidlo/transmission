*get the ad8045 circuit file
.INCLUDE ad8045.cir

C1 input1 n1 .1u
R1 n1 in_p 5K
*5K taken out to increase create gain on this by 1/5th while boosting video signals to x5
C2 input2 n2 .1u
R2 n2 in_p 1K
C3 input3 n3 .1u
R3 n3 in_p 1K
R4 input4 in_p 100K
RA in- nvirt 100
*50
RB out in- 900
*120
CB out in- 10pF
X1  in_p in- out nvcc 0 AD8045

*create vin and power for opamp
*pulse(V_low V_high start_delay high_time period_time)
*sin(dc_offset amplitude freq)

*VIN input1 0 pulse(0 5 0 0 0 35n 71n)
VIN input1 0 DC 0 AC sin(1.5 2.5 14300K)
 VIN2 input2 0 sin(0 .2 66000K)
* VIN2 input2 0 DC 0
VIN3 input3 0 sin(0 .2 69000K)
* VIN3 input3 0 DC 0
VIN4 input4 0 DC 2.5

VCC nvcc 0 DC 5
VCCvirt nvirt 0 DC 2.5

.control

	*simulate 5 periods @ 14MHz
	tran 3.57n 357n
	plot out n1 n2 n3
	run
*	plot fourier 11 input1 vs fourier 11 input2
.endc
