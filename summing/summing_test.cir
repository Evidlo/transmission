*file changed from summing.cir to accomodate only 3 inputs on prototype-transmitter
*get the ad8045 circuit file
.INCLUDE ad8045.cir

R1 resistor1 in+ 5K
R2 resistor2 in+ 1K
*R3 input3 in+ 1K
R4 input4 in+ 1K
C1 input1 resistor1 .1u
C2 input2 resistor2 .1u
RA in- nvirt 200
RB out in- 220
*CB out in- 10pF
X1  in+ in- out nvcc 0 AD8045

*create vin and power for opamp
*pulse(V_low V_high start_delay high_time period_time)
*sin(dc_offset amplitude freq)

VIN input1 0 pulse(0 5 0 0 0 35n 71n)
*VIN input1 0 sin(2.5 5 14000K)
VIN2 input2 0 sin(0.0 .05 66000K)
*VIN3 input3 0 sin(2.5 .05 69000K)
VIN4 input4 0 DC 2.5

VCC nvcc 0 DC 5
VCCvirt nvirt 0 DC 2.5

.control

	*simulate 5 periods @ 14MHz
	tran 1.79n .357u
*	plot "in+"
	plot input1 input2
	plot resistor1 resistor2
	plot out
	run
*	plot fourier 11 input1 vs fourier 11 input2
.endc
