*Comparatorsd
.INCLUDE ad8045.cir

*Voltages*
Vin nin 0 sin(2.5 1 14000k)
Vo n0 0 5 DC

*Components*
R44  n0 1 1.5k
R45 1 0 1.6k
C55 1 0 .1n
Rt nout 0 100
x1 1 nin nout n0 0 AD8045

.control
*Simulates 5 periods at 14Mhz
	tran 1.79ns .321us
*Graphs input and output of Superdiode
	plot  v(1) v(nout) V(nin)
	run
.endc
